# Keil uVision project 20170331_First.uvprojx, settings and files
target First (ARM-ADS)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 20170331_First +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\STM32F0xx\Include;.\Driver;.\MAIN;.\SPL\inc;.\Utils;.\CMSIS\core
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Driver
    ./Driver/: nrf24.c
  group MAIN
    ./MAIN/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group SPL
    ./SPL/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group startup
    ./startup/: startup_stm32f030.s
  group Utils
    ./Driver/: utils.c
